Commit message: added jump_opt

File: spinjorr.urdf (robot description, URDF)
Before this commit: robot spinjorr, 3 links, 2 joints
Links:
- link pendulum_link: geometry collision cylinder length=0.12 radius=0.01; visual cylinder length=0.12 radius=0.01
